inherit setuptools3
require python-nptyping.inc
