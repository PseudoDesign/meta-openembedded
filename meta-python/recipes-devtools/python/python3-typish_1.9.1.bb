inherit setuptools3
require python-typish.inc
