inherit setuptools3
require python-func-timeout.inc
